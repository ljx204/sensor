# Keil uVision project ble_sensor.uvprojx, settings and files
target nrf52832_xxaa (5060960::V5.06 update 7 (build 960)::.\armcompile5)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: app +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: PPG_SCHEDULER_ENABLE APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=24576 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\components\boards;..\build;..\components\libraries\bsp;..\components\util;..\modules\nrfx\drivers\include;..\components\utf_converter;..\modules\nrfx\hal;..\modules\nrfx\drivers;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\modules\nrfx;..\components\experimental_section_vars;..\components\libraries\experimental_section_vars;..\components\libraries\log;..\components\libraries\strerror;..\components\libraries\log\src;..\components\libraries\sortlist;..\integration\nrfx;..\components\libraries\timer;..\integration\nrfx\legacy;..\components\libraries\delay;..\components\segger_rtt;..\components\softdevice\common;..\components\ble\ble_advertising;..\components\libraries\atomic;..\components\ble\peer_manager;..\components\ble\nrf_ble_qwr;..\components\ble\nrf_ble_gatt;..\components\ble\common;..\components\libraries\fds;..\components\libraries\memobj;..\components\libraries\button;..\components\libraries\gpiote;..\components\libraries\atomic_flags;..\components\libraries\mutex;..\components\libraries\balloc;..\components\fprintf;..\components\libraries\ringbuf;..\components\libraries\sensorsim;..\components\libraries\pwr_mgmt;..\components\libraries\util;..\components\libraries\atomic_fifo;..\components\libraries\fstorage;..\src\stk832x;..\src\app_profile;..\src\app;..\src\button;..\src\protocol;..\src\app_ble;..\src\app_dfu;..\src\app_gatt;..\src\app_i2c;..\src\app_sec;..\src\pah8009\sensor;..\src\pah8009\bsp;..\components\ble\ble_services\ble_dfu;..\components\libraries\bootloader;..\components\libraries\bootloader\ble_dfu;..\components\libraries\svc;..\components\libraries\bootloader\dfu;..\src\pah8009\sensor;..\src\pah8009\algorithm\pah_hr\V303009;..\src\pah8009\algorithm\pah_spo2\V703;..\src\pah8009\algorithm\pah_stress\V6033;..\components\libraries\uart;..\src\pah8009;..\src\device_profile;..\components\libraries\scheduler;..\src\stk832x\algorithm_inc;..\src\info_profile;..\components\ble\ble_link_ctx_manager;..\src\app_adc_battery;..\src\app_pedometer
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=7,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\components\nfc\platform;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200026d0 size 0xd930
  link misc: --diag_suppress 6330
  group Application
    ../src/: main.c
    ./: sdk_config.h
    ../src/app/: app.c app_process_data.c
    ../src/app_ble/: app_ble.c
    ../src/app_dfu/: app_dfu.c
    ../src/app_gatt/: app_gatt.c
    ../src/app_i2c/: app_i2c.c
    ../src/app_sec/: app_sec.c
  group Board Definition
    ../components/boards/: boards.c
  group Board Support
    ../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    ../components/utf_converter/: utf.c
  group nRF_BLE
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c peer_data_storage.c security_manager.c pm_buffer.c security_dispatcher.c peer_manager_handler.c peer_manager.c peer_id.c peer_database.c
    ../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
  group nRF_Drivers
    ../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c nrf_drv_twi.c nrf_drv_ppi.c
    ../modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_uarte.c nrfx_uart.c nrfx_clock.c nrfx_twi.c nrfx_twim.c nrfx_rtc.c nrfx_timer.c nrfx_saadc.c nrfx_ppi.c
    ../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../components/libraries/atomic/: nrf_atomic.c
    ../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../components/libraries/atomic_flags/: nrf_atflags.c
    ../components/libraries/balloc/: nrf_balloc.c
    ../components/libraries/fds/: fds.c
    ../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../components/libraries/memobj/: nrf_memobj.c
    ../components/libraries/ringbuf/: nrf_ringbuf.c
    ../components/libraries/fstorage/: nrf_fstorage_sd.c nrf_fstorage.c
    ../components/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../components/libraries/strerror/: nrf_strerror.c
    ../components/libraries/gpiote/: app_gpiote.c
    ../components/libraries/uart/: app_uart.c app_uart_fifo.c
  group nRF_Log
    ../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../components/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group OTA
    ../components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
    ../components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group PHA8009
    ../src/pah8009/sensor/: pah_800x.c pah800x_bsp.c pah800x_main.c
    ../src/pah8009/bsp/: pxi_nrf_system_clock.c pxi_nrf_gpio.c
    ../src/pah8009/: app_pah8009.c
  group algorithm_lib
    ../src/pah8009/algorithm/pah_hr/V303009/: paw_v303009_0_m4f_keil.lib
    ../src/pah8009/algorithm/pah_spo2/V703/: pxialg_spo2_v703_0_0_m4f_keil.lib
    ../src/pah8009/algorithm/pah_stress/V6033/: pixart_sdnn6033_0_m4f_keil.lib
    ../src/app_pedometer/: stkMotion.lib
  group info_profile
    ../src/info_profile/: info_profile.c info_profile_task.c
  group uart_profile
    ../src/app_profile/: app_uart_task.c ble_uart.c
  group protocol
    ../src/protocol/: bd_communicate_protocol.c bd_crc16.c
  group battery
    ../src/app_adc_battery/: app_saadc.c
  group pedometer
    ../src/app_pedometer/: app_motion.c
target flash_s132_nrf52_7.2.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s132_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002250 size 0xddb0
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.40.3
